File: plate/fr4/bakeneko-60-fr4-plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 285.8 x 95.3 mm, 0 parts

Commit message: Upgrade to Kicad 6
Other:
- net class Default removed
